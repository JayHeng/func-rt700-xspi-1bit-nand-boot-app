<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\led_romapi_cm33_core0.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>all</name>
            <member>
                <project>gpio_led_output_cm33_core0</project>
                <configuration>flash_debug</configuration>
            </member>
            <member>
                <project>gpio_led_output_cm33_core0</project>
                <configuration>flash_release</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>flash_debug</name>
            <member>
                <project>gpio_led_output_cm33_core0</project>
                <configuration>flash_debug</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>flash_release</name>
            <member>
                <project>gpio_led_output_cm33_core0</project>
                <configuration>flash_release</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
